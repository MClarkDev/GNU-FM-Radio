options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: radio
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: fPrefix
  id: variable
  parameters:
    value: '"T0-"'
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: fqBB
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 0,0,1,1
    maximum: '1100'
    minimum: '850'
    scaleFactor: 1e5
    showvalue: 'True'
    type: real
    value: '1000'
  states: {}
- name: fqT1
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,0,1,1
    maximum: int(+(sample_rate/2)/1e5)
    minimum: int(-(sample_rate/2)/1e5)
    scaleFactor: 1e5
    showvalue: 'True'
    type: real
    value: int(+(sample_rate/4)/1e5)
  states: {}
- name: fqT2
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,7,1,1
    maximum: int(+(sample_rate/2)/1e5)
    minimum: int(-(sample_rate/2)/1e5)
    scaleFactor: 1e5
    showvalue: 'True'
    type: real
    value: int(-(sample_rate/4)/1e5)
  states: {}
- name: fqT3
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 2,0,1,1
    maximum: int(+(sample_rate/2)/1e5)
    minimum: int(-(sample_rate/2)/1e5)
    scaleFactor: 1e5
    showvalue: 'True'
    type: real
    value: int(+(sample_rate/4)/1e5)
  states: {}
- name: fqT4
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 2,7,1,1
    maximum: int(+(sample_rate/2)/1e5)
    minimum: int(-(sample_rate/2)/1e5)
    scaleFactor: 1e5
    showvalue: 'True'
    type: real
    value: int(-(sample_rate/4)/1e5)
  states: {}
- name: gainBB
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 0,7,1,1
    maximum: '40'
    minimum: '0'
    showvalue: 'True'
    type: real
    value: '36'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: analog_wfm_rcv_0_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: analog_wfm_rcv_0_2
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fPrefix + "stream-1.dat"
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fPrefix + "stream-2.dat"
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_wavfile_sink_0_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fPrefix + "stream-3.dat"
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_wavfile_sink_0_2
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fPrefix + "stream-4.dat"
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +(.5*sample_rate)
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +(.5*sample_rate)
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +(.5*sample_rate)
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +(.5*sample_rate)
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '192000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: (sample_rate)
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '192000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: (sample_rate)
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '192000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: (sample_rate)
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '192000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: (sample_rate)
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2001'
    type: float
  states: {}
- name: network_tcp_sink_0_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2002'
    type: float
  states: {}
- name: network_tcp_sink_0_0_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2003'
    type: float
  states: {}
- name: network_tcp_sink_0_0_2
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2004'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '50'
    freq0: fqBB
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: gainBB
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,3
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,4,1,3
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,6
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,3
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_3
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,4,1,3
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_rcv_0_1, '0', rational_resampler_xxx_0_1, '0']
- [analog_wfm_rcv_0_2, '0', rational_resampler_xxx_0_2, '0']
- [fqT1, value, freq_xlating_fir_filter_xxx_0, freq]
- [fqT2, value, freq_xlating_fir_filter_xxx_0_0, freq]
- [fqT3, value, freq_xlating_fir_filter_xxx_0_1, freq]
- [fqT4, value, freq_xlating_fir_filter_xxx_0_2, freq]
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', low_pass_filter_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', low_pass_filter_0_0_0_2, '0']
- [low_pass_filter_0_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0_0_0, '0', analog_wfm_rcv_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_0_0_1, '0', analog_wfm_rcv_0_1, '0']
- [low_pass_filter_0_0_0_1, '0', qtgui_waterfall_sink_x_0_2, '0']
- [low_pass_filter_0_0_0_2, '0', analog_wfm_rcv_0_2, '0']
- [low_pass_filter_0_0_0_2, '0', qtgui_waterfall_sink_x_0_3, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', network_tcp_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', network_tcp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_wavfile_sink_0_1, '0']
- [rational_resampler_xxx_0_1, '0', network_tcp_sink_0_0_1, '0']
- [rational_resampler_xxx_0_2, '0', blocks_wavfile_sink_0_2, '0']
- [rational_resampler_xxx_0_2, '0', network_tcp_sink_0_0_2, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_2, '0']

metadata:
  file_format: 1
