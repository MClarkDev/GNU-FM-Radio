options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: radio
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: fm_sample
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: stream_1-5.wav
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: stream_2-5.wav
    format: FORMAT_WAV
    samp_rate: int(audio_rate)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '500000'
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-300000'
    decim: '1'
    samp_rate: sample_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: 1e6
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: int(sample_rate/fm_sample)
    gain: '1'
    samp_rate: 1e6
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '36'
    freq0: '93200000'
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0_0_0, '0', analog_wfm_rcv_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
